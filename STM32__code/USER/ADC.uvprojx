# Keil uVision project ADC.uvprojx, settings and files
target ADC (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x00080000) IRAM(0x20000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ADC +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\HARDWARE\LCD;..\HARDWARE\RTC;..\HARDWARE\RTC;..\HARDWARE\WKUP;..\HARDWARE\ADC;..\MATH;..\SYSTEM\DSP;..\SYSTEM\feature_extraction;..\SYSTEM\IIC;..\SYSTEM\pca;..\SYSTEM\timer;..\SYSTEM\sys;..\SYSTEM\usart
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c ALL_DATA.h ALL_DEFINE.h
  group HARDWARE
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/ADC/: adc.c
    ./: scheduler.c
    ../MATH/: network_evaluate.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c uart3.c
    ../SYSTEM/IIC/: myiic.c
    ../SYSTEM/pca/: pca9685.c
    ../SYSTEM/feature_extraction/: myfeature.c
    ../SYSTEM/DSP/: arm_cortexM3l_math.lib arm_math.h cr4_fft_256_stm32.s cr4_fft_1024_stm32.s stm32_dsp.h
    ../MATH/: filter.c myMath.c
    ../SYSTEM/timer/: TIM.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_dma.c stm32f10x_tim.c
  group README
    ../: README.TXT
